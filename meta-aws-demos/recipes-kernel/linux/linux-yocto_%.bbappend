FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://tls.cfg"
