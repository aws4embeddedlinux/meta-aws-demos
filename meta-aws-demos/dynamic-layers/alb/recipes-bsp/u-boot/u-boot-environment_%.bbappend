FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

# build this env config u-boot-biga.txt
UBOOT_ENV_NAME:s32g = "u-boot-biga"